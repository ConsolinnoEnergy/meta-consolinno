COMPATIBLE_MACHINE  = "consolinno-leaflet-1u0022-1"

CFGSET = "\
    ${_CFGSET_COMMON} \
"

PATCHSET = "\
    file://0000-generic.patch \
"
