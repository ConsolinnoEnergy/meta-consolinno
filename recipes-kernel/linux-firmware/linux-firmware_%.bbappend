SYSROOT_DIRS_IGNORE:remove = "${nonarch_base_libdir}/firmware"
