RDEPENDS:${PN} += "\
    ${PYTHON_PN}-distutils \
"
