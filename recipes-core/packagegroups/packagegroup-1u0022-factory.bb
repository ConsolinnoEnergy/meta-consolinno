## --*- bitbake -*--

inherit packagegroup

RDEPENDS:${PN} += "\
    1u0022-setup-factory \
"
