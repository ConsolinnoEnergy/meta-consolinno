SUBPATH = "system"

require 1u0022-setup.inc

RDEPENDS:${PN} += "\
"
