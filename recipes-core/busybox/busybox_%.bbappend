FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += "\
    file://1u0022.cfg \
"
