require 1u0022-common.inc
require 1u0022-initrd.inc

IMAGE_INSTALL += "packagegroup-1u0022-initrd"

PROVIDES = "virtual/initrd-system"
